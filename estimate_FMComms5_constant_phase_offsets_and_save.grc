<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.11'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>estimate_X310_TwinRX_constant_phase_offsets_and_save</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
<param><key>run_options</key><value>run</value></param>
</block>
<block>
<key>variable_struct</key>
<param><key>id</key><value>input_variables</value></param>
<param><key>value2</key><value>2450000000</value></param>
<param><key>comment</key><value>input_variables: 
Contains all the user-defined variables.</value></param>
<param><key>value6</key><value>"/tmp"</value></param>
<param><key>field0</key><value>SampleRate</value></param>
<param><key>field1</key><value>ToneFreq</value></param>
<param><key>field2</key><value>CenterFreq</value></param>
<param><key>field3</key><value>Gain</value></param>
<param><key>field4</key><value>NumArrayElements</value></param>
<param><key>field5</key><value>RxAddr</value></param>
<param><key>field6</key><value>DirectoryConfigFiles</value></param>
<param><key>field7</key><value>RelativePhaseOffsets</value></param>
<param><key>field8</key><value>SkipAhead</value></param>
<param><key>field9</key><value>Samples2FindMax</value></param>
<param><key>value3</key><value>60</value></param>
<param><key>value4</key><value>4</value></param>
<param><key>value7</key><value>"measure_X310_TwinRX_relative_phase_offsets_245.cfg"</value></param>
<param><key>value5</key><value>"addr=192.168.10.2"</value></param>
<param><key>value0</key><value>10000000</value></param>
<param><key>value9</key><value>2**11</value></param>
<param><key>value8</key><value>2**15</value></param>
<param><key>value1</key><value>10000</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>rel_phase_offsets_file_name</value></param>
<param><key>value</key><value>os.path.join(input_variables.DirectoryConfigFiles, input_variables.RelativePhaseOffsets)</value></param>
</block>
<block>
<key>doa_findmax_and_save</key>
<param><key>id</key><value>doa_findmax_and_save_0</value></param>
<param><key>config_filename</key><value>rel_phase_offsets_file_name</value></param>
<param><key>num_inputs</key><value>input_variables.NumArrayElements-1</value></param>
<param><key>samples_to_findmax</key><value>input_variables.Samples2FindMax</value></param>
</block>
<block>
<key>doa_twinrx_phase_offset_est</key>
<param><key>id</key><value>doa_twinrx_phase_offset_est_0</value></param>
<param><key>num_inputs</key><value>input_variables.NumArrayElements</value></param>
<param><key>n_skip_ahead</key><value>input_variables.SkipAhead</value></param>
</block>
<block>
<key>iio_fmcomms5_source</key>
<param><key>id</key><value>iio_fmcomms5_source_0</value></param>
<param><key>bbdc</key><value>True</value></param>
<param><key>buffer_size</key><value>0x8000</value></param>
<param><key>ch1_en</key><value>True</value></param>
<param><key>ch2_en</key><value>True</value></param>
<param><key>ch3_en</key><value>True</value></param>
<param><key>ch4_en</key><value>True</value></param>
<param><key>decimation</key><value>1</value></param>
<param><key>filter</key><value></value></param>
<param><key>gain1</key><value>"slow_attack"</value></param>
<param><key>gain2</key><value>"slow_attack"</value></param>
<param><key>gain3</key><value>"slow_attack"</value></param>
<param><key>gain4</key><value>"slow_attack"</value></param>
<param><key>uri</key><value>ip:192.168.3.2</value></param>
<param><key>frequency1</key><value>input_variables.CenterFreq</value></param>
<param><key>frequency2</key><value>input_variables.CenterFreq</value></param>
<param><key>manual_gain1</key><value>input_variables.Gain</value></param>
<param><key>manual_gain2</key><value>input_variables.Gain</value></param>
<param><key>manual_gain3</key><value>input_variables.Gain</value></param>
<param><key>manual_gain4</key><value>input_variables.Gain</value></param>
<param><key>quadrature</key><value>True</value></param>
<param><key>rfdc</key><value>True</value></param>
<param><key>rf_port_select</key><value>"A_BALANCED"</value></param>
<param><key>bandwidth</key><value>input_variables.SampleRate</value></param>
<param><key>samplerate</key><value>input_variables.SampleRate</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import</value></param>
<param><key>import</key><value>import os</value></param>
</block>
<connection><source_block_id>doa_twinrx_phase_offset_est_0</source_block_id><sink_block_id>doa_findmax_and_save_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>doa_twinrx_phase_offset_est_0</source_block_id><sink_block_id>doa_findmax_and_save_0</sink_block_id><source_key>1</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>doa_twinrx_phase_offset_est_0</source_block_id><sink_block_id>doa_findmax_and_save_0</sink_block_id><source_key>2</source_key><sink_key>2</sink_key></connection>
<connection><source_block_id>iio_fmcomms5_source_0</source_block_id><sink_block_id>doa_twinrx_phase_offset_est_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>iio_fmcomms5_source_0</source_block_id><sink_block_id>doa_twinrx_phase_offset_est_0</sink_block_id><source_key>1</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>iio_fmcomms5_source_0</source_block_id><sink_block_id>doa_twinrx_phase_offset_est_0</sink_block_id><source_key>2</source_key><sink_key>2</sink_key></connection>
<connection><source_block_id>iio_fmcomms5_source_0</source_block_id><sink_block_id>doa_twinrx_phase_offset_est_0</sink_block_id><source_key>3</source_key><sink_key>3</sink_key></connection>
</flow_graph>
