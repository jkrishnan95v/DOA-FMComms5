<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.14'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>calibrate_lin_array_X310_TwinRX</value></param>
<param><key>generate_options</key><value>no_gui</value></param>
<param><key>run_options</key><value>run</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>antenna_calibration_file_name</value></param>
<param><key>value</key><value>os.path.join(input_variables.DirectoryConfigFiles, input_variables.AntennaCalibration)</value></param>
</block>
<block>
<key>variable_struct</key>
<param><key>id</key><value>input_variables</value></param>
<param><key>value12</key><value>"calibration_lin_array_245.cfg"</value></param>
<param><key>value2</key><value>2450000000</value></param>
<param><key>comment</key><value>input_variables: 
Contains all the user-defined variables.</value></param>
<param><key>value10</key><value>"/tmp"</value></param>
<param><key>field0</key><value>ToneFreq</value></param>
<param><key>field1</key><value>SampleRate</value></param>
<param><key>field10</key><value>DirectoryConfigFiles</value></param>
<param><key>field11</key><value>RelativePhaseOffsets</value></param>
<param><key>field12</key><value>AntennaCalibration</value></param>
<param><key>field13</key><value>Samples2Avg</value></param>
<param><key>field2</key><value>CenterFreq</value></param>
<param><key>field3</key><value>RxAddr</value></param>
<param><key>field4</key><value>Gain</value></param>
<param><key>field5</key><value>NumArrayElements</value></param>
<param><key>field6</key><value>NormSpacing</value></param>
<param><key>field7</key><value>SnapshotSize</value></param>
<param><key>field8</key><value>OverlapSize</value></param>
<param><key>field9</key><value>PilotAngle</value></param>
<param><key>value4</key><value>60</value></param>
<param><key>value6</key><value>0.5</value></param>
<param><key>value5</key><value>4</value></param>
<param><key>value8</key><value>2**9</value></param>
<param><key>value9</key><value>45.0</value></param>
<param><key>value11</key><value>"measure_X310_TwinRX_relative_phase_offsets_245.cfg"</value></param>
<param><key>value3</key><value>"addr=192.168.10.2"</value></param>
<param><key>value1</key><value>10000000</value></param>
<param><key>value13</key><value>2**11</value></param>
<param><key>value7</key><value>2**11</value></param>
<param><key>value0</key><value>10000</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>rel_phase_offsets_file_name</value></param>
<param><key>value</key><value>os.path.join(input_variables.DirectoryConfigFiles, input_variables.RelativePhaseOffsets)</value></param>
</block>
<block>
<key>blocks_complex_to_magphase</key>
<param><key>id</key><value>blocks_complex_to_magphase_0</value></param>
<param><key>vlen</key><value>input_variables.NumArrayElements</value></param>
</block>
<block>
<key>doa_autocorrelate</key>
<param><key>id</key><value>doa_autocorrelate_0</value></param>
<param><key>avg_method</key><value>1</value></param>
<param><key>inputs</key><value>input_variables.NumArrayElements</value></param>
<param><key>overlap_size</key><value>input_variables.OverlapSize</value></param>
<param><key>snapshot_size</key><value>input_variables.SnapshotSize</value></param>
</block>
<block>
<key>doa_calibrate_lin_array</key>
<param><key>id</key><value>doa_calibrate_lin_array_0</value></param>
<param><key>norm_spacing</key><value>input_variables.NormSpacing</value></param>
<param><key>num_ant_ele</key><value>input_variables.NumArrayElements</value></param>
<param><key>pilot_angle</key><value>input_variables.PilotAngle</value></param>
</block>
<block>
<key>doa_save_antenna_calib</key>
<param><key>id</key><value>doa_save_antenna_calib_0</value></param>
<param><key>config_filename</key><value>antenna_calibration_file_name</value></param>
<param><key>num_inputs</key><value>input_variables.NumArrayElements</value></param>
<param><key>samples_to_average</key><value>input_variables.Samples2Avg</value></param>
</block>
<block>
<key>iio_fmcomms5_source</key>
<param><key>id</key><value>iio_fmcomms5_source_0_0</value></param>
<param><key>bbdc</key><value>True</value></param>
<param><key>buffer_size</key><value>0x8000</value></param>
<param><key>ch1_en</key><value>True</value></param>
<param><key>ch2_en</key><value>True</value></param>
<param><key>ch3_en</key><value>True</value></param>
<param><key>ch4_en</key><value>True</value></param>
<param><key>filter</key><value></value></param>
<param><key>gain1</key><value>"slow_attack"</value></param>
<param><key>gain2</key><value>"slow_attack"</value></param>
<param><key>gain3</key><value>"slow_attack"</value></param>
<param><key>gain4</key><value>"slow_attack"</value></param>
<param><key>uri</key><value>ip:192.168.3.2</value></param>
<param><key>frequency1</key><value>input_variables.CenterFreq</value></param>
<param><key>frequency2</key><value>input_variables.CenterFreq</value></param>
<param><key>manual_gain1</key><value>input_variables.Gain</value></param>
<param><key>manual_gain2</key><value>input_variables.Gain</value></param>
<param><key>manual_gain3</key><value>input_variables.Gain</value></param>
<param><key>manual_gain4</key><value>input_variables.Gain</value></param>
<param><key>quadrature</key><value>True</value></param>
<param><key>rfdc</key><value>True</value></param>
<param><key>rf_port_select</key><value>"A_BALANCED"</value></param>
<param><key>bandwidth</key><value>input_variables.SampleRate</value></param>
<param><key>samplerate</key><value>input_variables.SampleRate</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import</value></param>
<param><key>import</key><value>import os</value></param>
</block>
<block>
<key>phase_correct_hier</key>
<param><key>id</key><value>phase_correct_hier_1</value></param>
<param><key>config_filename</key><value>rel_phase_offsets_file_name</value></param>
<param><key>num_ports</key><value>input_variables.NumArrayElements</value></param>
</block>
<connection><source_block_id>blocks_complex_to_magphase_0</source_block_id><sink_block_id>doa_save_antenna_calib_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_complex_to_magphase_0</source_block_id><sink_block_id>doa_save_antenna_calib_0</sink_block_id><source_key>1</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>doa_autocorrelate_0</source_block_id><sink_block_id>doa_calibrate_lin_array_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>doa_calibrate_lin_array_0</source_block_id><sink_block_id>blocks_complex_to_magphase_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>iio_fmcomms5_source_0_0</source_block_id><sink_block_id>phase_correct_hier_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>iio_fmcomms5_source_0_0</source_block_id><sink_block_id>phase_correct_hier_1</sink_block_id><source_key>1</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>iio_fmcomms5_source_0_0</source_block_id><sink_block_id>phase_correct_hier_1</sink_block_id><source_key>2</source_key><sink_key>2</sink_key></connection>
<connection><source_block_id>iio_fmcomms5_source_0_0</source_block_id><sink_block_id>phase_correct_hier_1</sink_block_id><source_key>3</source_key><sink_key>3</sink_key></connection>
<connection><source_block_id>phase_correct_hier_1</source_block_id><sink_block_id>doa_autocorrelate_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>phase_correct_hier_1</source_block_id><sink_block_id>doa_autocorrelate_0</sink_block_id><source_key>1</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>phase_correct_hier_1</source_block_id><sink_block_id>doa_autocorrelate_0</sink_block_id><source_key>2</source_key><sink_key>2</sink_key></connection>
<connection><source_block_id>phase_correct_hier_1</source_block_id><sink_block_id>doa_autocorrelate_0</sink_block_id><source_key>3</source_key><sink_key>3</sink_key></connection>
</flow_graph>
