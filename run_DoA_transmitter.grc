<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.14'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>run_DoA_transmitter</value></param>
<param><key>generate_options</key><value>no_gui</value></param>
</block>
<block>
<key>variable_struct</key>
<param><key>id</key><value>input_variables</value></param>
<param><key>value2</key><value>2450000000</value></param>
<param><key>comment</key><value>input_variables: 
Contains all the user-defined variables.</value></param>
<param><key>field0</key><value>ToneFreq</value></param>
<param><key>field1</key><value>SampleRate</value></param>
<param><key>field2</key><value>CenterFreq</value></param>
<param><key>field3</key><value>TxAddr</value></param>
<param><key>field4</key><value>Gain</value></param>
<param><key>value4</key><value>20</value></param>
<param><key>value1</key><value>1000000</value></param>
<param><key>value0</key><value>10000</value></param>
<param><key>value3</key><value>"addr=169.254.197.15"</value></param>
</block>
<block>
<key>analog_sig_source_x</key>
<param><key>id</key><value>analog_sig_source_x_0</value></param>
<param><key>amp</key><value>1</value></param>
<param><key>freq</key><value>input_variables.ToneFreq</value></param>
<param><key>offset</key><value>0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>samp_rate</key><value>input_variables.SampleRate</value></param>
<param><key>waveform</key><value>analog.GR_COS_WAVE</value></param>
</block>
<block>
<key>uhd_usrp_sink</key>
<param><key>id</key><value>uhd_usrp_sink_0</value></param>
<param><key>ant0</key><value></value></param>
<param><key>center_freq0</key><value>input_variables.CenterFreq</value></param>
<param><key>norm_gain0</key><value>False</value></param>
<param><key>gain0</key><value>input_variables.Gain</value></param>
<param><key>clock_rate</key><value>0.0</value></param>
<param><key>dev_addr</key><value>input_variables.TxAddr</value></param>
<param><key>dev_args</key><value>""</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>clock_source0</key><value>internal</value></param>
<param><key>samp_rate</key><value>input_variables.SampleRate</value></param>
<param><key>hide_cmd_port</key><value>False</value></param>
<param><key>hide_lo_controls</key><value>True</value></param>
<param><key>sync</key><value></value></param>
<param><key>len_tag_name</key><value></value></param>
</block>
<connection><source_block_id>analog_sig_source_x_0</source_block_id><sink_block_id>uhd_usrp_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
